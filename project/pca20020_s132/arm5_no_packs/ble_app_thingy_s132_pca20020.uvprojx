# Keil uVision project ble_app_thingy_s132_pca20020.uvprojx, settings and files
target release_v1_0_0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_thingy_s132 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF52 NRF52832 NRF52832_XXAA BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=4 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT=1 BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND
  c include: ..\config;..\..\..\external\sdk13_override;..\..\..\external\segger_rtt;..\..\..\include\ble_services;..\..\..\include\board;..\..\..\include\drivers;..\..\..\include\macros;..\..\..\include\modules;..\..\..\include\util;..\..\..\libs\bv32fp-1.2;..\..\..\libs\dvi_adpcm;..\..\..\libs\eMD6\core\driver\eMPL;..\..\..\libs\eMD6\core\driver\include;..\..\..\libs\eMD6\core\driver\nRF52;..\..\..\libs\eMD6\core\eMPL-hal;..\..\..\libs\eMD6\core\mllite;..\..\..\libs\eMD6\core\mpl;..\..\..\libs\sr3_audio;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\ble\ble_services\ble_bas;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\ble\common;..\..\..\sdk_components\drivers_nrf\clock;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\pdm;..\..\..\sdk_components\drivers_nrf\pwm;..\..\..\sdk_components\drivers_nrf\rng;..\..\..\sdk_components\drivers_nrf\saadc;..\..\..\sdk_components\drivers_nrf\twi_master;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\bootloader\dfu;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\crc32;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\libraries\fds;..\..\..\sdk_components\libraries\fifo;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\led_softblink;..\..\..\sdk_components\libraries\log;..\..\..\sdk_components\libraries\log\src;..\..\..\sdk_components\libraries\low_power_pwm;..\..\..\sdk_components\libraries\queue;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\strerror\;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\nfc\ndef\generic\message;..\..\..\sdk_components\nfc\ndef\generic\record;..\..\..\sdk_components\nfc\ndef\launchapp;..\..\..\sdk_components\nfc\ndef\text;..\..\..\sdk_components\nfc\ndef\uri;..\..\..\sdk_components\nfc\t2t_lib;..\..\..\sdk_components\nfc\t2t_lib\hal_t2t;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\tools\sound;..\..\..\sdk_components\libraries\pwm;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\drivers_nrf\timer;..\..\..\sdk_components\drivers_nrf\ppi
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x200042a0 size 0xbd60
  group Thingy
    ../: main.c
    ../../../source/modules/: m_ble.c m_ble_flash.c m_environment.c m_environment_flash.c m_motion.c m_motion_flash.c m_ui.c m_ui_flash.c m_sound.c m_batt_meas.c
    ../../../source/util/: advertiser_beacon_timeslot.c twi_manager.c support_func.c
    ../config/: sdk_config.h thingy_config.h
    ../../../include/board/: pca20020.h
  group Thingy drivers
    ../../../source/drivers/: drv_ext_light.c drv_ccs811.c drv_gas_sensor.c drv_bh1745.c drv_color.c drv_speaker.c drv_mpu9250.c drv_motion.c drv_acc_lis3dh.c drv_pressure.c drv_lps22hb.c drv_sx1509.c drv_hts221.c drv_humidity.c drv_ext_gpio.c drv_mic.c drv_nfc.c drv_pwm.c
    ../../../source/util/: sx150x_led_drv_calc.c
  group Thingy_libraries
    ../../../libs/libmpllib_Keil_M4FP/: libmpllib.lib
    ../../../libs/eMD6/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../../libs/eMD6/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../../libs/eMD6/core/eMPL-hal/: eMPL_outputs.c
    ../../../libs/eMD6/core/driver/nRF52/: log_nrf52.c
  group nRF_BLE
    ../../../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../sdk_components/ble/ble_advertising/: ble_advertising.c
    ../../../source/ble_services/: ble_tes.c ble_tcs.c ble_uis.c ble_tms.c ble_tss.c
    ../../../sdk_components/ble/ble_services/ble_bas/: ble_bas.c
  group nRF_Drivers
    ../../../sdk_components/drivers_nrf/common/: nrf_drv_common.c
    ../../../sdk_components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../sdk_components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../sdk_components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../sdk_components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../sdk_components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../sdk_components/drivers_nrf/hal/: nrf_saadc.c
    ../../../sdk_components/drivers_nrf/pdm/: nrf_drv_pdm.c
    ../../../sdk_components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../sdk_components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../sdk_components/drivers_nrf/ppi/: nrf_drv_ppi.c
  group nRF_Libraries
    ../../../sdk_components/libraries/queue/: nrf_queue.c
    ../../../sdk_components/libraries/button/: app_button.c
    ../../../sdk_components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c sdk_mapped_flags.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/timer/: app_timer.c
    ../../../sdk_components/libraries/uart/: retarget.c
    ../../../sdk_components/libraries/led_softblink/: led_softblink.c
    ../../../sdk_components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../sdk_components/libraries/fstorage/: fstorage.c
    ../../../sdk_components/libraries/fds/: fds.c
    ../../../sdk_components/libraries/crc32/: crc32.c
    ../../../sdk_components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../sdk_components/libraries/pwm/: app_pwm.c
  group nRF_SoftDevice
    ../../../external/sdk13/components/softdevice/s132/doc/: s132_nrf52_4.0.2_licence-agreement.txt
    ../../../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../external/sdk13_override/: softdevice_handler_appsh.c
  group nRF_Log
    ../../../sdk_components/libraries/log/src/: nrf_log_frontend.c nrf_log_backend_serial.c
    ../../../sdk_components/libraries/strerror/: nrf_strerror.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Codec: BV32FP
    ../../../libs/bv32fp-1.2/: a2lsp.c allpole.c allzero.c autocor.c bitpack.c bvplc.c cmtables.c coarptch.c decoder.c encoder.c excdec.c excquan.c fineptch.c gaindec.c gainquan.c levdur.c levelest.c lsp2a.c lspdec.c lspquan.c ptdec.c ptquan.c stblchck.c stblzlsp.c tables.c utility.c
  group Codec: ADPCM
    ../../../libs/dvi_adpcm/: dvi_adpcm.c
  group SR3_Audio
    ../../../libs/sr3_audio/: drv_audio_coder_adpcm.c drv_audio_coder_bv32fp.c drv_audio_dsp.c drv_audio_pdm.c
    ../config/: drv_audio_config.h
  group nRF_NFC
    ../../../sdk_components/nfc/t2t_lib/: nfc_t2t_lib_keil.lib
    ../../../sdk_components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../sdk_components/nfc/ndef/text/: nfc_text_rec.c
    ../../../sdk_components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../sdk_components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../sdk_components/nfc/ndef/uri/: nfc_uri_msg.c nfc_uri_rec.c
    ../../../sdk_components/nfc/ndef/launchapp/: nfc_launchapp_msg.c nfc_launchapp_rec.c
target release_v0_9_0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: as above
  output: app_thingy_s132 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF52 NRF52832 NRF52832_XXAA BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=4 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT=1 BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND THINGY_HW_v0_9_0
  c include: ..\config;..\..\..\external\sdk13_override;..\..\..\external\segger_rtt;..\..\..\include\ble_services;..\..\..\include\board;..\..\..\include\drivers;..\..\..\include\macros;..\..\..\include\modules;..\..\..\include\util;..\..\..\libs\bv32fp-1.2;..\..\..\libs\dvi_adpcm;..\..\..\libs\eMD6\core\driver\eMPL;..\..\..\libs\eMD6\core\driver\include;..\..\..\libs\eMD6\core\driver\nRF52;..\..\..\libs\eMD6\core\eMPL-hal;..\..\..\libs\eMD6\core\mllite;..\..\..\libs\eMD6\core\mpl;..\..\..\libs\sr3_audio;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\ble\ble_services\ble_bas;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\ble\common;..\..\..\sdk_components\drivers_nrf\clock;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\pdm;..\..\..\sdk_components\drivers_nrf\pwm;..\..\..\sdk_components\drivers_nrf\rng;..\..\..\sdk_components\drivers_nrf\saadc;..\..\..\sdk_components\drivers_nrf\twi_master;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\bootloader\dfu;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\crc32;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\libraries\fds;..\..\..\sdk_components\libraries\fifo;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\led_softblink;..\..\..\sdk_components\libraries\log;..\..\..\sdk_components\libraries\log\src;..\..\..\sdk_components\libraries\low_power_pwm;..\..\..\sdk_components\libraries\queue;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\strerror\;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\nfc\ndef\generic\message;..\..\..\sdk_components\nfc\ndef\generic\record;..\..\..\sdk_components\nfc\ndef\launchapp;..\..\..\sdk_components\nfc\ndef\text;..\..\..\sdk_components\nfc\ndef\uri;..\..\..\sdk_components\nfc\t2t_lib;..\..\..\sdk_components\nfc\t2t_lib\hal_t2t;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\tools\sound
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004170 size 0xbe90
target release_v0_8_0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: as above
  output: app_thingy_s132_hw_v0_8_0 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF52 NRF52832 NRF52832_XXAA BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=4 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT=1 BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND THINGY_HW_v0_8_0
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x20004170 size 0xbe90
target debug_v1_0_0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: as above
  output: app_thingy_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: NRF52 NRF52832 NRF52832_XXAA BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=4 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT SWI_DISABLE0 BSP_DEFINES_ONLY ARM_MATH_CM4 MPU9250 EMPL USE_DMP EMPL_TARGET_NRF52 NRF_LOG_USES_RTT=1 BLE_DFU_APP_SUPPORT NRF_DFU_SETTINGS_VERSION=1 AUDIO_EQ_DEF=3 HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND DEBUG NRF_LOG_ENABLED=1
  c misc: --c99
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x56000
  memory RVCT9: RAM 0x200042a0 size 0xbd60
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.1, CMSIS:DSP 1.5.2, Device:Startup 8.13.0
